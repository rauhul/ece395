# Keil uVision project test_proj.uvproj, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1114/202 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: test_proj
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MPU6050 ARM_CORTEX_M0
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group LPC11xx Core
    ./LPC11xx Core/: system_LPC11xx.c startup_LPC11xx.s
  group main
    ./: main.c
  group MPU6050 Core
    ./MPU6050 Core/: i2c.c inv_mpu.c inv_mpu_dmp_motion_driver.c m0_mpu_6050.c timer32.c
  group Serial Core
    ./Serial Core/: retarget.c serial.c
